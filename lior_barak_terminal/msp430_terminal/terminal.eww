<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\msp430x5xx\C-source\MSP430x5xx (C - SpyBiWire).ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\msp430x5xx\C-source\MSP430x5xx (C).ewp</path>
  </project>
  <batchBuild/>
</workspace>


